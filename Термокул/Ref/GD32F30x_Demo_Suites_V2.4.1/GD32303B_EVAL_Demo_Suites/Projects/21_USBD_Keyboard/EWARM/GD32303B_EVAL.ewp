# IAR project GD32303B_EVAL.ewp, settings and files
configuration USBD (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xB GD GD32F303xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities; ..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include; ..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbd_library\class\device\hid\Include; ..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbd_library\device\Include; ..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbd_library\usbd\Include; ..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32303E_EVAL.srec
  ILINK.IlinkOutputFile: GD32303B_EVAL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f30x_it.c gd32f30x_usbd_hw.c hid_keyboard_itf.c main.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../../../Utilities/: gd32f303b_eval.c
  group GD32F30x_Peripherals
    ../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
  group USBD_Class
    ../../../../GD32F30x_Firmware_Library/GD32F30x_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group USBD_Device
    ../../../../GD32F30x_Firmware_Library/GD32F30x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Drivers
    ../../../../GD32F30x_Firmware_Library/GD32F30x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
